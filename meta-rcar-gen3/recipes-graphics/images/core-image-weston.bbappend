require core-image-renesas-base.inc
require core-image-weston.inc

CORE_IMAGE_BASE_INSTALL += "weston-ini-conf"
